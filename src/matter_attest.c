/* SPDX-License-Identifier: ISC */

/*
 * See matter_attest.h, including what these credentials are and are not.
 *
 * The DER here is written BACKWARDS, from the last byte to the first. DER
 * prefixes every element with its content length, so a forward writer has to
 * either guess lengths and patch them or encode each nesting level into a
 * scratch buffer. Building from the end means the length is always already
 * known, which removes both -- at the cost that every helper prepends, so the
 * code reads inside-out relative to the structure it produces.
 */
#include <tinytalk/matter_attest.h>

#include <tinytalk/matter_tlv.h>

#include <stdbool.h>
#include <string.h>

/* DeviceAttestationConstructor.cpp:29-36 */
#define TAG_ELEM_CD        1u
#define TAG_ELEM_NONCE     2u
#define TAG_ELEM_TIMESTAMP 3u

/* DeviceAttestationConstructor.cpp:38-45 */
#define TAG_NOCSR_CSR   1u
#define TAG_NOCSR_NONCE 2u

/* DAC, X.509 DER, vendor 0xFFF1 product 0x8001 (ExampleDACs.cpp:73) (491 bytes) */
static const uint8_t k_dac[491] = {
	0x30, 0x82, 0x01, 0xe7, 0x30, 0x82, 0x01, 0x8e, 0xa0, 0x03, 0x02, 0x01, 0x02, 0x02, 0x08,
	0x69, 0xcd, 0xf1, 0x0d, 0xe9, 0xe5, 0x4e, 0xd1, 0x30, 0x0a, 0x06, 0x08, 0x2a, 0x86, 0x48,
	0xce, 0x3d, 0x04, 0x03, 0x02, 0x30, 0x3d, 0x31, 0x25, 0x30, 0x23, 0x06, 0x03, 0x55, 0x04,
	0x03, 0x0c, 0x1c, 0x4d, 0x61, 0x74, 0x74, 0x65, 0x72, 0x20, 0x44, 0x65, 0x76, 0x20, 0x50,
	0x41, 0x49, 0x20, 0x30, 0x78, 0x46, 0x46, 0x46, 0x31, 0x20, 0x6e, 0x6f, 0x20, 0x50, 0x49,
	0x44, 0x31, 0x14, 0x30, 0x12, 0x06, 0x0a, 0x2b, 0x06, 0x01, 0x04, 0x01, 0x82, 0xa2, 0x7c,
	0x02, 0x01, 0x0c, 0x04, 0x46, 0x46, 0x46, 0x31, 0x30, 0x20, 0x17, 0x0d, 0x32, 0x32, 0x30,
	0x32, 0x30, 0x35, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x5a, 0x18, 0x0f, 0x39, 0x39, 0x39,
	0x39, 0x31, 0x32, 0x33, 0x31, 0x32, 0x33, 0x35, 0x39, 0x35, 0x39, 0x5a, 0x30, 0x53, 0x31,
	0x25, 0x30, 0x23, 0x06, 0x03, 0x55, 0x04, 0x03, 0x0c, 0x1c, 0x4d, 0x61, 0x74, 0x74, 0x65,
	0x72, 0x20, 0x44, 0x65, 0x76, 0x20, 0x44, 0x41, 0x43, 0x20, 0x30, 0x78, 0x46, 0x46, 0x46,
	0x31, 0x2f, 0x30, 0x78, 0x38, 0x30, 0x30, 0x31, 0x31, 0x14, 0x30, 0x12, 0x06, 0x0a, 0x2b,
	0x06, 0x01, 0x04, 0x01, 0x82, 0xa2, 0x7c, 0x02, 0x01, 0x0c, 0x04, 0x46, 0x46, 0x46, 0x31,
	0x31, 0x14, 0x30, 0x12, 0x06, 0x0a, 0x2b, 0x06, 0x01, 0x04, 0x01, 0x82, 0xa2, 0x7c, 0x02,
	0x02, 0x0c, 0x04, 0x38, 0x30, 0x30, 0x31, 0x30, 0x59, 0x30, 0x13, 0x06, 0x07, 0x2a, 0x86,
	0x48, 0xce, 0x3d, 0x02, 0x01, 0x06, 0x08, 0x2a, 0x86, 0x48, 0xce, 0x3d, 0x03, 0x01, 0x07,
	0x03, 0x42, 0x00, 0x04, 0x46, 0x3a, 0xc6, 0x93, 0x42, 0x91, 0x0a, 0x0e, 0x55, 0x88, 0xfc,
	0x6f, 0xf5, 0x6b, 0xb6, 0x3e, 0x62, 0xec, 0xce, 0xcb, 0x14, 0x8f, 0x7d, 0x4e, 0xb0, 0x3e,
	0xe5, 0x52, 0x60, 0x14, 0x15, 0x76, 0x7d, 0x16, 0xa5, 0xc6, 0x63, 0xf7, 0x93, 0xe4, 0x91,
	0x23, 0x26, 0x0b, 0x82, 0x97, 0xa7, 0xcd, 0x7e, 0x7c, 0xfc, 0x7b, 0x31, 0x6b, 0x39, 0xd9,
	0x8e, 0x90, 0xd2, 0x93, 0x77, 0x73, 0x8e, 0x82, 0xa3, 0x60, 0x30, 0x5e, 0x30, 0x0c, 0x06,
	0x03, 0x55, 0x1d, 0x13, 0x01, 0x01, 0xff, 0x04, 0x02, 0x30, 0x00, 0x30, 0x0e, 0x06, 0x03,
	0x55, 0x1d, 0x0f, 0x01, 0x01, 0xff, 0x04, 0x04, 0x03, 0x02, 0x07, 0x80, 0x30, 0x1d, 0x06,
	0x03, 0x55, 0x1d, 0x0e, 0x04, 0x16, 0x04, 0x14, 0x88, 0xdd, 0xe7, 0xb3, 0x00, 0x38, 0x29,
	0x32, 0xcf, 0xf7, 0x34, 0xc0, 0x46, 0x24, 0x81, 0x0f, 0x44, 0x16, 0x8a, 0x6f, 0x30, 0x1f,
	0x06, 0x03, 0x55, 0x1d, 0x23, 0x04, 0x18, 0x30, 0x16, 0x80, 0x14, 0x63, 0x54, 0x0e, 0x47,
	0xf6, 0x4b, 0x1c, 0x38, 0xd1, 0x38, 0x84, 0xa4, 0x62, 0xd1, 0x6c, 0x19, 0x5d, 0x8f, 0xfb,
	0x3c, 0x30, 0x0a, 0x06, 0x08, 0x2a, 0x86, 0x48, 0xce, 0x3d, 0x04, 0x03, 0x02, 0x03, 0x47,
	0x00, 0x30, 0x44, 0x02, 0x20, 0x01, 0x27, 0xa2, 0x7b, 0x4b, 0x44, 0x61, 0x0e, 0xe2, 0xfc,
	0xdc, 0x4d, 0x2b, 0x78, 0x85, 0x56, 0x36, 0x60, 0xbc, 0x0f, 0x76, 0xf1, 0x72, 0x19, 0xed,
	0x6a, 0x08, 0xdf, 0xb2, 0xb3, 0xc1, 0xcd, 0x02, 0x20, 0x6b, 0x59, 0xe0, 0xaf, 0x45, 0xf3,
	0xeb, 0x2a, 0x85, 0xb9, 0x19, 0xd3, 0x57, 0x31, 0x52, 0x8c, 0x60, 0x28, 0xc4, 0x15, 0x23,
	0x95, 0x45, 0xe1, 0x08, 0xe4, 0xe5, 0x4e, 0x70, 0x97, 0x13, 0x53,
};

/* PAI, X.509 DER, vendor 0xFFF1 (ExamplePAI.cpp:32) (463 bytes) */
static const uint8_t k_pai[463] = {
	0x30, 0x82, 0x01, 0xcb, 0x30, 0x82, 0x01, 0x71, 0xa0, 0x03, 0x02, 0x01, 0x02, 0x02, 0x08,
	0x56, 0xad, 0x82, 0x22, 0xad, 0x94, 0x5b, 0x64, 0x30, 0x0a, 0x06, 0x08, 0x2a, 0x86, 0x48,
	0xce, 0x3d, 0x04, 0x03, 0x02, 0x30, 0x30, 0x31, 0x18, 0x30, 0x16, 0x06, 0x03, 0x55, 0x04,
	0x03, 0x0c, 0x0f, 0x4d, 0x61, 0x74, 0x74, 0x65, 0x72, 0x20, 0x54, 0x65, 0x73, 0x74, 0x20,
	0x50, 0x41, 0x41, 0x31, 0x14, 0x30, 0x12, 0x06, 0x0a, 0x2b, 0x06, 0x01, 0x04, 0x01, 0x82,
	0xa2, 0x7c, 0x02, 0x01, 0x0c, 0x04, 0x46, 0x46, 0x46, 0x31, 0x30, 0x20, 0x17, 0x0d, 0x32,
	0x32, 0x30, 0x32, 0x30, 0x35, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x5a, 0x18, 0x0f, 0x39,
	0x39, 0x39, 0x39, 0x31, 0x32, 0x33, 0x31, 0x32, 0x33, 0x35, 0x39, 0x35, 0x39, 0x5a, 0x30,
	0x3d, 0x31, 0x25, 0x30, 0x23, 0x06, 0x03, 0x55, 0x04, 0x03, 0x0c, 0x1c, 0x4d, 0x61, 0x74,
	0x74, 0x65, 0x72, 0x20, 0x44, 0x65, 0x76, 0x20, 0x50, 0x41, 0x49, 0x20, 0x30, 0x78, 0x46,
	0x46, 0x46, 0x31, 0x20, 0x6e, 0x6f, 0x20, 0x50, 0x49, 0x44, 0x31, 0x14, 0x30, 0x12, 0x06,
	0x0a, 0x2b, 0x06, 0x01, 0x04, 0x01, 0x82, 0xa2, 0x7c, 0x02, 0x01, 0x0c, 0x04, 0x46, 0x46,
	0x46, 0x31, 0x30, 0x59, 0x30, 0x13, 0x06, 0x07, 0x2a, 0x86, 0x48, 0xce, 0x3d, 0x02, 0x01,
	0x06, 0x08, 0x2a, 0x86, 0x48, 0xce, 0x3d, 0x03, 0x01, 0x07, 0x03, 0x42, 0x00, 0x04, 0x41,
	0x9a, 0x93, 0x15, 0xc2, 0x17, 0x3e, 0x0c, 0x8c, 0x87, 0x6d, 0x03, 0xcc, 0xfc, 0x94, 0x48,
	0x52, 0x64, 0x7f, 0x7f, 0xec, 0x5e, 0x50, 0x82, 0xf4, 0x05, 0x99, 0x28, 0xec, 0xa8, 0x94,
	0xc5, 0x94, 0x15, 0x13, 0x09, 0xac, 0x63, 0x1e, 0x4c, 0xb0, 0x33, 0x92, 0xaf, 0x68, 0x4b,
	0x0b, 0xaf, 0xb7, 0xe6, 0x5b, 0x3b, 0x81, 0x62, 0xc2, 0xf5, 0x2b, 0xf9, 0x31, 0xb8, 0xe7,
	0x7a, 0xaa, 0x82, 0xa3, 0x66, 0x30, 0x64, 0x30, 0x12, 0x06, 0x03, 0x55, 0x1d, 0x13, 0x01,
	0x01, 0xff, 0x04, 0x08, 0x30, 0x06, 0x01, 0x01, 0xff, 0x02, 0x01, 0x00, 0x30, 0x0e, 0x06,
	0x03, 0x55, 0x1d, 0x0f, 0x01, 0x01, 0xff, 0x04, 0x04, 0x03, 0x02, 0x01, 0x06, 0x30, 0x1d,
	0x06, 0x03, 0x55, 0x1d, 0x0e, 0x04, 0x16, 0x04, 0x14, 0x63, 0x54, 0x0e, 0x47, 0xf6, 0x4b,
	0x1c, 0x38, 0xd1, 0x38, 0x84, 0xa4, 0x62, 0xd1, 0x6c, 0x19, 0x5d, 0x8f, 0xfb, 0x3c, 0x30,
	0x1f, 0x06, 0x03, 0x55, 0x1d, 0x23, 0x04, 0x18, 0x30, 0x16, 0x80, 0x14, 0x6a, 0xfd, 0x22,
	0x77, 0x1f, 0x51, 0x1f, 0xec, 0xbf, 0x16, 0x41, 0x97, 0x67, 0x10, 0xdc, 0xdc, 0x31, 0xa1,
	0x71, 0x7e, 0x30, 0x0a, 0x06, 0x08, 0x2a, 0x86, 0x48, 0xce, 0x3d, 0x04, 0x03, 0x02, 0x03,
	0x48, 0x00, 0x30, 0x45, 0x02, 0x21, 0x00, 0xb2, 0xef, 0x27, 0xf4, 0x9a, 0xe9, 0xb5, 0x0f,
	0xb9, 0x1e, 0xea, 0xc9, 0x4c, 0x4d, 0x0b, 0xdb, 0xb8, 0xd7, 0x92, 0x9c, 0x6c, 0xb8, 0x8f,
	0xac, 0xe5, 0x29, 0x36, 0x8d, 0x12, 0x05, 0x4c, 0x0c, 0x02, 0x20, 0x65, 0x5d, 0xc9, 0x2b,
	0x86, 0xbd, 0x90, 0x98, 0x82, 0xa6, 0xc6, 0x21, 0x77, 0xb8, 0x25, 0xd7, 0xd0, 0x5e, 0xdb,
	0xe7, 0xc2, 0x2f, 0x9f, 0xea, 0x71, 0x22, 0x0e, 0x7e, 0xa7, 0x03, 0xf8, 0x91,
};

/* Certification Declaration, CMS SignedData (DeviceAttestationCredsExample.cpp:135) (539 bytes) */
static const uint8_t k_cd[539] = {
	0x30, 0x82, 0x02, 0x17, 0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x07, 0x02,
	0xa0, 0x82, 0x02, 0x08, 0x30, 0x82, 0x02, 0x04, 0x02, 0x01, 0x03, 0x31, 0x0d, 0x30, 0x0b,
	0x06, 0x09, 0x60, 0x86, 0x48, 0x01, 0x65, 0x03, 0x04, 0x02, 0x01, 0x30, 0x82, 0x01, 0x70,
	0x06, 0x09, 0x2a, 0x86, 0x48, 0x86, 0xf7, 0x0d, 0x01, 0x07, 0x01, 0xa0, 0x82, 0x01, 0x61,
	0x04, 0x82, 0x01, 0x5d, 0x15, 0x24, 0x00, 0x01, 0x25, 0x01, 0xf1, 0xff, 0x36, 0x02, 0x05,
	0x00, 0x80, 0x05, 0x01, 0x80, 0x05, 0x02, 0x80, 0x05, 0x03, 0x80, 0x05, 0x04, 0x80, 0x05,
	0x05, 0x80, 0x05, 0x06, 0x80, 0x05, 0x07, 0x80, 0x05, 0x08, 0x80, 0x05, 0x09, 0x80, 0x05,
	0x0a, 0x80, 0x05, 0x0b, 0x80, 0x05, 0x0c, 0x80, 0x05, 0x0d, 0x80, 0x05, 0x0e, 0x80, 0x05,
	0x0f, 0x80, 0x05, 0x10, 0x80, 0x05, 0x11, 0x80, 0x05, 0x12, 0x80, 0x05, 0x13, 0x80, 0x05,
	0x14, 0x80, 0x05, 0x15, 0x80, 0x05, 0x16, 0x80, 0x05, 0x17, 0x80, 0x05, 0x18, 0x80, 0x05,
	0x19, 0x80, 0x05, 0x1a, 0x80, 0x05, 0x1b, 0x80, 0x05, 0x1c, 0x80, 0x05, 0x1d, 0x80, 0x05,
	0x1e, 0x80, 0x05, 0x1f, 0x80, 0x05, 0x20, 0x80, 0x05, 0x21, 0x80, 0x05, 0x22, 0x80, 0x05,
	0x23, 0x80, 0x05, 0x24, 0x80, 0x05, 0x25, 0x80, 0x05, 0x26, 0x80, 0x05, 0x27, 0x80, 0x05,
	0x28, 0x80, 0x05, 0x29, 0x80, 0x05, 0x2a, 0x80, 0x05, 0x2b, 0x80, 0x05, 0x2c, 0x80, 0x05,
	0x2d, 0x80, 0x05, 0x2e, 0x80, 0x05, 0x2f, 0x80, 0x05, 0x30, 0x80, 0x05, 0x31, 0x80, 0x05,
	0x32, 0x80, 0x05, 0x33, 0x80, 0x05, 0x34, 0x80, 0x05, 0x35, 0x80, 0x05, 0x36, 0x80, 0x05,
	0x37, 0x80, 0x05, 0x38, 0x80, 0x05, 0x39, 0x80, 0x05, 0x3a, 0x80, 0x05, 0x3b, 0x80, 0x05,
	0x3c, 0x80, 0x05, 0x3d, 0x80, 0x05, 0x3e, 0x80, 0x05, 0x3f, 0x80, 0x05, 0x40, 0x80, 0x05,
	0x41, 0x80, 0x05, 0x42, 0x80, 0x05, 0x43, 0x80, 0x05, 0x44, 0x80, 0x05, 0x45, 0x80, 0x05,
	0x46, 0x80, 0x05, 0x47, 0x80, 0x05, 0x48, 0x80, 0x05, 0x49, 0x80, 0x05, 0x4a, 0x80, 0x05,
	0x4b, 0x80, 0x05, 0x4c, 0x80, 0x05, 0x4d, 0x80, 0x05, 0x4e, 0x80, 0x05, 0x4f, 0x80, 0x05,
	0x50, 0x80, 0x05, 0x51, 0x80, 0x05, 0x52, 0x80, 0x05, 0x53, 0x80, 0x05, 0x54, 0x80, 0x05,
	0x55, 0x80, 0x05, 0x56, 0x80, 0x05, 0x57, 0x80, 0x05, 0x58, 0x80, 0x05, 0x59, 0x80, 0x05,
	0x5a, 0x80, 0x05, 0x5b, 0x80, 0x05, 0x5c, 0x80, 0x05, 0x5d, 0x80, 0x05, 0x5e, 0x80, 0x05,
	0x5f, 0x80, 0x05, 0x60, 0x80, 0x05, 0x61, 0x80, 0x05, 0x62, 0x80, 0x05, 0x63, 0x80, 0x18,
	0x24, 0x03, 0x16, 0x2c, 0x04, 0x13, 0x43, 0x53, 0x41, 0x30, 0x30, 0x30, 0x30, 0x30, 0x53,
	0x57, 0x43, 0x30, 0x30, 0x30, 0x30, 0x30, 0x2d, 0x30, 0x30, 0x24, 0x05, 0x00, 0x24, 0x06,
	0x00, 0x24, 0x07, 0x01, 0x24, 0x08, 0x00, 0x18, 0x31, 0x7c, 0x30, 0x7a, 0x02, 0x01, 0x03,
	0x80, 0x14, 0xfe, 0x34, 0x3f, 0x95, 0x99, 0x47, 0x76, 0x3b, 0x61, 0xee, 0x45, 0x39, 0x13,
	0x13, 0x38, 0x49, 0x4f, 0xe6, 0x7d, 0x8e, 0x30, 0x0b, 0x06, 0x09, 0x60, 0x86, 0x48, 0x01,
	0x65, 0x03, 0x04, 0x02, 0x01, 0x30, 0x0a, 0x06, 0x08, 0x2a, 0x86, 0x48, 0xce, 0x3d, 0x04,
	0x03, 0x02, 0x04, 0x46, 0x30, 0x44, 0x02, 0x20, 0x4a, 0x12, 0xf8, 0xd4, 0x2f, 0x90, 0x23,
	0x5c, 0x05, 0xa7, 0x71, 0x21, 0xcb, 0xeb, 0xae, 0x15, 0xd5, 0x90, 0x14, 0x65, 0x58, 0xe9,
	0xc9, 0xb4, 0x7a, 0x1a, 0x38, 0xf7, 0xa3, 0x6a, 0x7d, 0xc5, 0x02, 0x20, 0x20, 0xa4, 0x74,
	0x28, 0x97, 0xc3, 0x0a, 0xed, 0xa0, 0xa5, 0x6b, 0x36, 0xe1, 0x4e, 0xbb, 0xc8, 0x5b, 0xbd,
	0xb7, 0x44, 0x93, 0xf9, 0x93, 0x58, 0x1e, 0xb0, 0x44, 0x4e, 0xd6, 0xca, 0x94, 0x0b,
};

/* DAC private key, P-256 scalar (32 bytes) */
static const uint8_t k_dac_key[32] = {
	0xaa, 0xb6, 0x00, 0xae, 0x8a, 0xe8, 0xaa, 0xb7, 0xd7, 0x36, 0x27,
	0xc2, 0x17, 0xb7, 0xc2, 0x04, 0x70, 0x9c, 0xa6, 0x94, 0x6a, 0xf5,
	0xf2, 0xf7, 0x53, 0x08, 0x33, 0xa5, 0x2b, 0x44, 0xfb, 0xff,
};

/**
 * Retrieve a prepacked attestation certificate (DAC or PAI) by type. Returns MATTER_OK and fills
 * out and len on success, or MATTER_E_INVAL if type is not recognized or arguments are NULL.
 */
int matter_attest_cert(uint8_t type, const uint8_t **out, size_t *len)
{
	if (out == NULL || len == NULL) {
		return MATTER_E_INVAL;
	}
	if (type == MATTER_CERT_TYPE_DAC) {
		*out = k_dac;
		*len = sizeof(k_dac);
		return MATTER_OK;
	}
	if (type == MATTER_CERT_TYPE_PAI) {
		*out = k_pai;
		*len = sizeof(k_pai);
		return MATTER_OK;
	}
	return MATTER_E_INVAL;
}

/**
 * Encode and return the attestation elements (nonce, timestamp, certification declaration) as a TLV
 * structure. Validates nonce, timestamp, out, and out_len pointers. Returns MATTER_OK on success or
 * MATTER_E_INVAL if any pointer is NULL.
 */
int matter_attest_elements_encode(const uint8_t *nonce, size_t nonce_len, uint32_t timestamp,
				  uint8_t *out, size_t cap, size_t *out_len)
{
	struct matter_tlv_writer w;

	if (nonce == NULL || out == NULL || out_len == NULL) {
		return MATTER_E_INVAL;
	}

	matter_tlv_writer_init(&w, out, cap);
	(void)matter_tlv_start_container(&w, MATTER_TLV_ANON, MATTER_TLV_STRUCTURE);
	/* Ascending tags, enforced by the peer's deconstructor. */
	(void)matter_tlv_put_bytes(&w, MATTER_TLV_CTX(TAG_ELEM_CD), k_cd, sizeof(k_cd));
	(void)matter_tlv_put_bytes(&w, MATTER_TLV_CTX(TAG_ELEM_NONCE), nonce, nonce_len);
	(void)matter_tlv_put_u64(&w, MATTER_TLV_CTX(TAG_ELEM_TIMESTAMP), timestamp);
	(void)matter_tlv_end_container(&w);

	return matter_tlv_writer_finish(&w, out_len);
}

/**
 * Encode the CSR and nonce as a TLV-encoded CertificateChainResponse payload. Validates all input
 * pointers. Returns MATTER_OK on success or MATTER_E_INVAL if any pointer is NULL.
 */
int matter_attest_nocsr_encode(const uint8_t *csr, size_t csr_len, const uint8_t *nonce,
			       size_t nonce_len, uint8_t *out, size_t cap, size_t *out_len)
{
	struct matter_tlv_writer w;

	if (csr == NULL || nonce == NULL || out == NULL || out_len == NULL) {
		return MATTER_E_INVAL;
	}

	matter_tlv_writer_init(&w, out, cap);
	(void)matter_tlv_start_container(&w, MATTER_TLV_ANON, MATTER_TLV_STRUCTURE);
	(void)matter_tlv_put_bytes(&w, MATTER_TLV_CTX(TAG_NOCSR_CSR), csr, csr_len);
	(void)matter_tlv_put_bytes(&w, MATTER_TLV_CTX(TAG_NOCSR_NONCE), nonce, nonce_len);
	(void)matter_tlv_end_container(&w);

	return matter_tlv_writer_finish(&w, out_len);
}

/**
 * Sign a payload plus challenge with the DAC private key. Appends the challenge to the buffer,
 * signs the combined data, and clears the challenge bytes before returning. Returns MATTER_OK on
 * success, MATTER_E_INVAL if any pointer is NULL, MATTER_E_NOSPACE if the buffer has insufficient
 * room, or MATTER_E_STATE if the signature operation fails.
 */
int matter_attest_sign_with_challenge(uint8_t *buf, size_t payload_len, size_t cap,
				      const uint8_t *challenge, size_t challenge_len,
				      uint8_t sig[MATTER_ATTEST_SIG_LEN])
{
	int rc;

	if (buf == NULL || challenge == NULL || sig == NULL) {
		return MATTER_E_INVAL;
	}
	if (cap < payload_len || cap - payload_len < challenge_len) {
		return MATTER_E_NOSPACE;
	}

	memcpy(buf + payload_len, challenge, challenge_len);
	rc = matter_attest_ecdsa_sign(k_dac_key, buf, payload_len + challenge_len, sig);
	/* Leave the buffer holding exactly the payload again. The challenge is
	 * session key material and has no business outliving its use. */
	memset(buf + payload_len, 0, challenge_len);

	return (rc == 0) ? MATTER_OK : MATTER_E_STATE;
}

/* --------------------------------------------------------------- DER --- */

/**
 * A backwards DER writer: @ref pos walks down from the end of the buffer, and
 * everything already written lives in buf[pos..cap).
 */
struct der {
	uint8_t *buf;
	size_t cap;
	size_t pos;
	bool bad;
};

/**
 * Prepend raw bytes to the DER encoding buffer. Marks the buffer bad if there is insufficient
 * space.
 */
static void der_raw(struct der *d, const uint8_t *src, size_t len)
{
	if (d->bad || d->pos < len) {
		d->bad = true;
		return;
	}
	d->pos -= len;
	memcpy(d->buf + d->pos, src, len);
}

/**
 * Append one byte to the DER encoding buffer by prepending it to the existing bytes. Marks buffer
 * bad if insufficient space.
 */
static void der_byte(struct der *d, uint8_t b)
{
	der_raw(d, &b, 1u);
}

/** Prepend a tag and the length of the @p len bytes already written. */
static void der_hdr(struct der *d, uint8_t tag, size_t len)
{
	if (d->bad) {
		return;
	}
	if (len < 0x80u) {
		der_byte(d, (uint8_t)len);
	} else if (len <= 0xFFu) {
		der_byte(d, (uint8_t)len);
		der_byte(d, 0x81u);
	} else {
		der_byte(d, (uint8_t)(len & 0xFFu));
		der_byte(d, (uint8_t)(len >> 8));
		der_byte(d, 0x82u);
	}
	der_byte(d, tag);
}

/** How many bytes are written so far, for computing the enclosing length. */
static size_t der_len(const struct der *d)
{
	return d->cap - d->pos;
}

/*
 * OIDs, DER-encoded including their 0x06 tag and length. Standard and stable;
 * the definitive check that they are right is that OpenSSL parses the CSR this
 * builds, which tests/host/test_matter_attest.py does.
 */
static const uint8_t k_oid_ou[] = {0x06, 0x03, 0x55, 0x04, 0x0B}; /* 2.5.4.11 */
static const uint8_t k_oid_ec_pubkey[] = {0x06, 0x07, 0x2A, 0x86, 0x48,
					  0xCE, 0x3D, 0x02, 0x01}; /* 1.2.840.10045.2.1 */
static const uint8_t k_oid_p256[] = {0x06, 0x08, 0x2A, 0x86, 0x48,
				     0xCE, 0x3D, 0x03, 0x01, 0x07}; /* ...10045.3.1.7 */
static const uint8_t k_oid_ecdsa_sha256[] = {0x06, 0x08, 0x2A, 0x86, 0x48,
					     0xCE, 0x3D, 0x04, 0x03, 0x02}; /* ...4.3.2 */
static const uint8_t k_oid_ext_req[] = {0x06, 0x09, 0x2A, 0x86, 0x48, 0x86,
					0xF7, 0x0D, 0x01, 0x09, 0x0E}; /* ...1.9.14 */

#define DER_SEQUENCE   0x30u
#define DER_SET        0x31u
#define DER_INTEGER    0x02u
#define DER_BIT_STRING 0x03u
#define DER_UTF8       0x0Cu
#define DER_CTX0       0xA0u /* context-specific, constructed, tag 0 */

/**
 * Prepend one of the signature's two integers.
 *
 * DER integers are SIGNED, so a 32-byte value whose top bit is set needs a
 * leading zero or it reads as negative -- and leading zero bytes must otherwise
 * be dropped. Getting either wrong produces a CSR that parses and fails to
 * verify.
 */
static void der_int(struct der *d, const uint8_t *v, size_t len)
{
	size_t i = 0u;
	size_t n;
	bool pad;

	if (len == 0u) {
		d->bad = true;
		return;
	}
	/* Leading zeros are not allowed, but at least one byte must remain. */
	while (i < len - 1u && v[i] == 0u) {
		i++;
	}
	n = len - i;
	/* Top bit set would read as a negative number; a zero byte fixes it. */
	pad = (v[i] & 0x80u) != 0u;

	der_raw(d, v + i, n);
	if (pad) {
		der_byte(d, 0u);
	}
	der_hdr(d, DER_INTEGER, n + (pad ? 1u : 0u));
}

/**
 * CertificationRequestInfo, the part that gets signed, INCLUDING its own
 * SEQUENCE wrapper.
 *
 * Wrapping itself matters: on the second pass this is prepended to a buffer
 * that already holds the signature, so a caller adding the wrapper afterwards
 * would measure the whole buffer and enclose the signature as well.
 */
static void der_cri(struct der *d, const uint8_t pub[65])
{
	const size_t start = der_len(d);
	size_t mark;

	/* attributes [0]: one empty extensionRequest. */
	mark = der_len(d);
	der_hdr(d, DER_SEQUENCE, 0u); /* the empty inner SEQUENCE */
	der_hdr(d, DER_SET, der_len(d) - mark);
	der_raw(d, k_oid_ext_req, sizeof(k_oid_ext_req));
	der_hdr(d, DER_SEQUENCE, der_len(d) - mark);
	der_hdr(d, DER_CTX0, der_len(d) - mark);

	/* subjectPublicKeyInfo. */
	mark = der_len(d);
	der_raw(d, pub, 65u);
	der_byte(d, 0u); /* unused bits */
	der_hdr(d, DER_BIT_STRING, 66u);
	{
		size_t alg = der_len(d);

		der_raw(d, k_oid_p256, sizeof(k_oid_p256));
		der_raw(d, k_oid_ec_pubkey, sizeof(k_oid_ec_pubkey));
		der_hdr(d, DER_SEQUENCE, der_len(d) - alg);
	}
	der_hdr(d, DER_SEQUENCE, der_len(d) - mark);

	/* subject: OU="CSA". A placeholder, because the commissioner replaces
	 * the whole subject when it issues the NOC (CHIPCryptoPAL.cpp:1084-85). */
	mark = der_len(d);
	der_raw(d, (const uint8_t *)"CSA", 3u);
	der_hdr(d, DER_UTF8, 3u);
	der_raw(d, k_oid_ou, sizeof(k_oid_ou));
	der_hdr(d, DER_SEQUENCE, der_len(d) - mark);
	der_hdr(d, DER_SET, der_len(d) - mark);
	der_hdr(d, DER_SEQUENCE, der_len(d) - mark);

	/* version INTEGER 0 */
	der_byte(d, 0u);
	der_hdr(d, DER_INTEGER, 1u);

	der_hdr(d, DER_SEQUENCE, der_len(d) - start);
}

int matter_attest_csr(const uint8_t priv[32], const uint8_t pub[65], uint8_t *out, size_t cap,
		      size_t *out_len)
{
	uint8_t sig[MATTER_ATTEST_SIG_LEN];
	struct der d;
	size_t cri_len;
	size_t body;
	int rc;

	if (priv == NULL || pub == NULL || out == NULL || out_len == NULL) {
		return MATTER_E_INVAL;
	}

	/*
	 * Two passes, for the reason CHIP gives at CHIPCryptoPAL.cpp:1136-1139:
	 * the signature covers CertificationRequestInfo, so it has to exist
	 * before the enclosing structure can be written, and finding its extent
	 * inside the finished object afterwards is harder than writing it twice.
	 * The first pass uses the output buffer as scratch -- nothing secret,
	 * and it is overwritten.
	 */
	d.buf = out;
	d.cap = cap;
	d.pos = cap;
	d.bad = false;
	der_cri(&d, pub);
	if (d.bad) {
		return MATTER_E_NOSPACE;
	}
	cri_len = der_len(&d);

	rc = matter_attest_ecdsa_sign(priv, out + d.pos, cri_len, sig);
	if (rc != 0) {
		return MATTER_E_STATE;
	}

	/* Second pass: the whole CertificationRequest. */
	d.pos = cap;
	d.bad = false;

	/* signature BIT STRING encapsulating Ecdsa-Sig-Value. */
	body = der_len(&d);
	der_int(&d, sig + 32, 32u); /* s */
	der_int(&d, sig, 32u);      /* r */
	der_hdr(&d, DER_SEQUENCE, der_len(&d) - body);
	der_byte(&d, 0u); /* unused bits */
	der_hdr(&d, DER_BIT_STRING, der_len(&d) - body);

	/* signatureAlgorithm. */
	body = der_len(&d);
	der_raw(&d, k_oid_ecdsa_sha256, sizeof(k_oid_ecdsa_sha256));
	der_hdr(&d, DER_SEQUENCE, der_len(&d) - body);

	der_cri(&d, pub);
	der_hdr(&d, DER_SEQUENCE, der_len(&d));

	memset(sig, 0, sizeof(sig));
	if (d.bad) {
		return MATTER_E_NOSPACE;
	}

	/* Built from the end, so shuffle it down to the front. */
	*out_len = der_len(&d);
	memmove(out, out + d.pos, *out_len);
	return MATTER_OK;
}
